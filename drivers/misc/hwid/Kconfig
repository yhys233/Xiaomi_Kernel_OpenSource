## drivers/misc/hwid/Kconfig
```kconfig
config MISC_HWID
    bool "Xiaomi HWID support"
    default y
    depends on MISC
```
